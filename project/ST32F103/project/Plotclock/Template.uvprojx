# Keil uVision project Template.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: ..\..\User;..\..\Libraries\CMSIS;..\..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\..\drive\led;..\..\Public;..\..\drive\beep;..\..\drive\smg;..\..\drive\key;..\..\drive\exti;..\..\drive\time;..\..\drive\pwm;..\..\drive\iwdg;..\..\drive\wwdg;..\..\drive\input;..\..\drive\touch_key;..\..\drive\wkup;..\..\drive\adc;..\..\drive\adc_temp;..\..\drive\dac;..\..\drive\pwm_dac;..\..\drive\dma;..\..\drive\rtc;..\..\drive\24Cxx;..\..\drive\iic;..\..\drive\ds18b20;..\..\drive\hwjs;..\..\drive\rs485;..\..\drive\can;..\..\drive\tftlcd;..\..\drive\spi;..\..\drive\nrf24l01;..\..\drive\dht11;..\..\drive\oled;..\..\drive\RC522;..\..\drive\Tetris;..\..\drive\ball;..\..\drive\touch;..\..\drive\snake;..\..\UCOSIII\uC-CPU;..\..\UCOSIII\uC-LIB;..\..\UCOSIII\uCOS-III;..\..\UCOSIII\UCOS_BSP;..\..\UCOSIII\uCOS_CONFIG;..\..\UCOSIII\uC-CPU\ARM-Cortex-M3\RealView;..\..\UCOSIII\uC-LIB\Ports\ARM-Cortex-M3\RealView;..\..\UCOSIII\uCOS-III\Ports\ARM-Cortex-M3\Generic\RealView;..\..\UCOSIII\uCOS-III\Source;..\..\drive\rtc_task;..\..\SEGGER_RTT_V758e\RTT;..\..\SEGGER_RTT_V758e\Config
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group User
    ../../User/: main.c stm32f10x_it.c
  group Startup
    ../../Libraries/CMSIS/: startup_stm32f10x_hd.s
  group StdPeriph_Driver
    ../../Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_gpio.c stm32f10x_rcc.c misc.c stm32f10x_exti.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_iwdg.c stm32f10x_wwdg.c stm32f10x_bkp.c stm32f10x_pwr.c stm32f10x_adc.c stm32f10x_dac.c stm32f10x_dma.c stm32f10x_rtc.c stm32f10x_can.c stm32f10x_fsmc.c stm32f10x_spi.c
  group CMSIS
    ../../Libraries/CMSIS/: system_stm32f10x.c core_cm3.c
  group APP
    ../../drive/led/: led.c
    ../../drive/tftlcd/: tftlcd.c
    ../../drive/rtc/: rtc.c
    ../../drive/rtc_task/: rtc_task.c
  group Public
    ../../Public/: system.c SysTick.c usart.c
  group UCOSIII_BSP
    ../../UCOSIII/UCOS_BSP/: bsp.c
  group UCOSIII_LIB
    ../../UCOSIII/uC-LIB/: lib_ascii.c lib_math.c lib_mem.c lib_str.c
    ../../UCOSIII/uC-LIB/Ports/ARM-Cortex-M3/RealView/: lib_mem_a.asm
  group UCOSIII_CPU
    ../../UCOSIII/uC-CPU/: cpu_core.c
    ../../UCOSIII/uC-CPU/ARM-Cortex-M3/RealView/: cpu_c.c cpu_a.asm
  group UCOSIII_CORE
    ../../UCOSIII/uCOS-III/Source/: os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
  group UCOSIII_PORT
    ../../UCOSIII/uCOS-III/Ports/ARM-Cortex-M3/Generic/RealView/: os_cpu.h os_cpu_a.s os_cpu_c.c
  group UCOSIII_CONFIG
    ../../UCOSIII/uCOS_CONFIG/: app_cfg.h cpu_cfg.h includes.h lib_cfg.h os_app_hooks.c os_app_hooks.h os_cfg.h os_cfg_app.h
  group SEGEER_RTT
    ../../SEGGER_RTT_V758e/RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
